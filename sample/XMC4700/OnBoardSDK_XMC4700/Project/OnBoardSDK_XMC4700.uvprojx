# Keil uVision project OnBoardSDK_XMC4700.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.7.1
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OnBoardSDK_XMC4700 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\User;..\Bsp;..\..\..\..\osdk-core\inc;.\OPTIGA Trust\SLS10ERE1\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group User
    ../User/: main.cpp driver.cpp Activate.cpp HotPoint.cpp LocalNavigation.cpp MobileCommand.cpp Receive.cpp VirtualRC.cpp cppforXMC4700.cpp
  group Bsp
    ../Bsp/: bsp.cpp BspUsart.cpp timer.cpp
  group doc
    ../doc/: readme.txt
  group DJIlib
    ../../../../osdk-core/src/: DJI_API.cpp DJI_App.cpp DJI_Camera.cpp DJI_Codec.cpp DJI_Flight.cpp DJI_Follow.cpp DJI_HardDriver.cpp DJI_HotPoint.cpp DJI_Link.cpp DJI_Logging.cpp DJI_Memory.cpp DJI_Mission.cpp DJI_VirtualRC.cpp DJI_WayPoint.cpp
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:RTE_Device 1.1.0, Device:Startup 2.0.0, Device:XMClib:CCU4 2.1.8, Device:XMClib:GPIO 2.1.8, Device:XMClib:SCU 2.1.8, Device:XMClib:UART 2.1.8
