# Keil uVision project OPTIGA Trust.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC4700-E196x1536 Infineon
  pack: Infineon.XMC4000_DFP.2.7.1
  cpu: IROM(0x08000000,0x180000) IROM2(0x0C000000,0x180000) IRAM(0x20000000,0x2CFC0) IRAM2(0x1FFE8000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT5: ROM 0xc000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x2cfc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group Source Group 1
    ./: main.c test_case.c board.c
  group Trust
    ./SLS10ERE1/: SLS10ERE_auth.c SLS10ERE_crypto.c SLS10ERE_math.c SLS10ERE_nvm.c SLS10ERE_SWI_BIF.c SWI_hal.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0, Device:XMClib:CCU4 2.1.4, Device:XMClib:GPIO 2.1.4, Device:XMClib:SCU 2.1.4
